# Keil uVision project lock.uvproj, settings and files
target 目标 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: lock +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\Public;.\App\LCD1602;.\App\LED;.\App\Button;.\App\Beep;.\App\Motor;.\App\Change;.\App\Paused;.\App\Eeprow
  group User
    ./User/: main.c
  group Public
    ./Public/: public.c
  group App
    ./App/LCD1602/: lcd1602.c
    ./App/LED/: led.c
    ./App/Button/: button.c
    ./App/Beep/: beep.c
    ./App/Motor/: motor.c
    ./App/Change/: change.c
    ./App/Paused/: paused.c
    ./App/Eeprow/: usingeeprow.c
  group System
    ./System/: STARTUP.A51
